## guests/zephyr/boards/riscv/baovm_cva6-spmp/board.yml
```yaml
board:
  name: baovm_cva6-spmp
  full_name: Bao guest for CVA6-SPMP
  vendor: osyx
  socs:
    - name: cv32a6
```
